# Keil uVision project traffic_light.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: traffic_light +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./HAL/: SEG_PRG.c SEG_INT.h
    ./LIB/: DELAY.c BIT_MATH.h DELAY_INT.h STD_TYPES.h
    ./MCAL/: DIO_PRG.c DIO_INT.h DIO_REG.h interrupt.c interrupt.h timer.c timer.h
    ./: main.c

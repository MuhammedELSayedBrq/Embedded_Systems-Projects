# Keil uVision project slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: slave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./LIB/: BIT_MATH.h DELAY.c DELAY_INT.h STD_TYPES.h
    ./HAL/: SEG_INT.h SEG_PRG.c
    ./MCAL/: DIO_INT.h DIO_PRG.c DIO_PRG.SRC DIO_REG.h interrupt.c interrupt.h timer.c timer.h
    ./: main.c
